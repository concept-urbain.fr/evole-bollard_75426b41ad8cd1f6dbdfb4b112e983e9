Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Evéole Borne.IFC
Time: 2020-07-01T13:30:50
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: EVEO-BOR-002-01_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 11.0456; Area Measure: 0.926134; Volume Measure: 0.0013807

# IfcBuildingElementProxy: EVEO-BOR-003_Default (2)
In: Default Storey
Material: AISI 316L
